# Repository simoninns/BeebSCSI

File README.md:

## Synopsis

BeebSCSI is a Micro SD Card based SCSI storage emulation for the Acorn 8-bit range of microcomputers including the Acorn BBC Model B (with ADFS) and the BBC Master 128.

Please see [the project wiki](https://github.com/simoninns/BeebSCSI/wiki) for detailed documentation on BeebSCSI

The project is divided into several sections:

BeebSCSI_AVR - This is the AT90USB1287 microcontroller firmware (written in GCC)

BeebSCSI_CPLD - This is the Xilinx XC9572XL CPLD firmware (written in ISE Verilog)

BeebSCSI_KiCAD - This folder contains the KiCAD schematics and PCB designed (V7_6 and above)

BeebSCSI_OpenSCAD - This folder contains a 3D printable case designed in OpenSCAD

BeebSCSI_ROM - This folder contains the 6502 assembly code for the BeebSCSI ROM

BeebSCSI_Utils - This folder contains BBC BASIC utilities for BeebSCSI

## Motivation

Originally Acorn provided a SCSI solution based on 3 individual parts: The Acorn SCSI host adapter, the Adaptec ACB-4000 SCSI adapter and a physical MFM hard disc (a ‘Winchester drive’). Later, as part of the Domesday project (in 1986), this was extended to include the AIV SCSI Host Adapter (designed to be connected internally to a BBC Master Turbo) and the Philips VP415 LaserVision laser disc player with SCSI-1 support.

BeebSCSI 7 is a credit-card sized board that provides a single-chip implementation of the host adapter board (both original and AIV) using a modern CPLD (Complex Programmable Logic Device). In addition, an AVR Microcontroller provides a complete SCSI-1 emulation including the vendor specific video control commands of the VP415.

Rather than using a physical hard drive, BeebSCSI uses a single Micro SD card to provide up to >64Gbytes of storage with support for either 4 (ADFS) or 8 (VFS) virtual hard drives (or ‘LUNs’) per card. In addition, in the BBC Master, two BeebSCSI devices can be attached, one internal and one external, providing 12 SCSI LUNs (hard drive images) simultaneously.

## Installation

Please see http://www.domesday86.com for detailed documentation on BeebSCSI

## Author

BeebSCSI is written and maintained by Simon Inns.

## Software License (GPLv3)

    BeebSCSI is free software: you can redistribute it and/or modify
    it under the terms of the GNU General Public License as published by
    the Free Software Foundation, either version 3 of the License, or
    (at your option) any later version.

    BeebSCSI is distributed in the hope that it will be useful,
    but WITHOUT ANY WARRANTY; without even the implied warranty of
    MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
    GNU General Public License for more details.

    You should have received a copy of the GNU General Public License
    along with BeebSCSI.  If not, see <http://www.gnu.org/licenses/>.
    
## Hardware License (Creative Commons BY-SA 4.0)

Please see the following link for details: https://creativecommons.org/licenses/by-sa/4.0/

You are free to:

Share - copy and redistribute the material in any medium or format
Adapt - remix, transform, and build upon the material
for any purpose, even commercially.

This license is acceptable for Free Cultural Works.

The licensor cannot revoke these freedoms as long as you follow the license terms.

Under the following terms:

Attribution - You must give appropriate credit, provide a link to the license, and indicate if changes were made. You may do so in any reasonable manner, but not in any way that suggests the licensor endorses you or your use.

ShareAlike - If you remix, transform, or build upon the material, you must distribute your contributions under the same license as the original.

No additional restrictions - You may not apply legal terms or technological measures that legally restrict others from doing anything the license permits.

## EAGLE design BeebSCSI_Eagle/BeebSCSI Internal Bus Adapter 1_4.brd

File BeebSCSI_Eagle/README.md:

## Synopsis

BeebSCSI is a Micro SD Card based SCSI storage emulation for the Acorn 8-bit range of microcomputers including the Acorn BBC Model B (with ADFS) and the BBC Master 128.

Please see http://www.domesday86.com for detailed documentation on BeebSCSI

The project is divided into several sections:

BeebSCSI_AVR - This is the AT90USB1287 microcontroller firmware (written in GCC)

BeebSCSI_CPLD - This is the Xilinx XC9572XL CPLD firmware (written in ISE Verilog)

BeebSCSI_Eagle - This folder contains the EagleCAD schematics and PCB designs

## Motivation

Originally Acorn provided a SCSI solution based on 3 individual parts: The Acorn SCSI host adapter, the Adaptec ACB-4000 SCSI adapter and a physical MFM hard disc (a Winchester drive). Later, as part of the Domesday project (in 1986), this was extended to include the AIV SCSI Host Adapter (designed to be connected internally to a BBC Master Turbo) and the Philips VP415 LaserVision laser disc player with SCSI-1 support.

BeebSCSI 7 is a credit-card sized board that provides a single-chip implementation of the host adapter board (both original and AIV) using a modern CPLD (Complex Programmable Logic Device). In addition, an AVR Microcontroller provides a complete SCSI-1 emulation including the vendor specific video control commands of the VP415.

Rather than using a physical hard drive, BeebSCSI uses a single Micro SD card to provide up to >64Gbytes of storage with support for either 4 (ADFS) or 8 (VFS) virtual hard drives (or LUNs) per card. In addition, in the BBC Master, two BeebSCSI devices can be attached, one internal and one external, providing 12 SCSI LUNs (hard drive images) simultaneously.

## Installation

Please see http://www.domesday86.com for detailed documentation on BeebSCSI

## Author

BeebSCSI is written and maintained by Simon Inns.

## License

    BeebSCSI is free software: you can redistribute it and/or modify
    it under the terms of the GNU General Public License as published by
    the Free Software Foundation, either version 3 of the License, or
    (at your option) any later version.

    BeebSCSI is distributed in the hope that it will be useful,
    but WITHOUT ANY WARRANTY; without even the implied warranty of
    MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
    GNU General Public License for more details.

    You should have received a copy of the GNU General Public License
    along with BeebSCSI.  If not, see <http://www.gnu.org/licenses/>.

Parts:
C1: 100nF; C0805
F1: SMD1206R500SF; F1812
IC1: 74HC245DW; SO20W
JP1: Power out; 1X03/90
X1: BBC-MASTER-INT-1MHZ-BUS-FE20W; FE20W
X2: BeebSCSI 1MHz Bus; 34-PIN-FLOPPY-CONNECTOR

Connections:
+5V: C1.1, F1.2, IC1.20 (VCC), JP1.2
GND: C1.2, IC1.1 (DIR), IC1.10 (GND), IC1.19 (G), JP1.1, JP1.3, X1.20 (0VB), X2.1, X2.3, X2.5, X2.7, X2.9, X2.11, X2.13, X2.15, X2.17, X2.31, X2.32, X2.33, X2.34
unnamed: IC1.18 (B1), X1.11 (!MODEM)
unnamed: IC1.17 (B2), X1.12 (A0)
unnamed: IC1.16 (B3), X1.13 (A1)
unnamed: X1.6 (BD3), X2.21
unnamed: X1.7 (BD4), X2.22
unnamed: X1.8 (BD5), X2.23
unnamed: X1.9 (BD6), X2.24
unnamed: X1.10 (BD7), X2.25
unnamed: IC1.15 (B4), X1.14 (A2)
unnamed: IC1.14 (B5), X1.15 (A3)
unnamed: IC1.13 (B6), X1.16 (1MHZE)
unnamed: IC1.12 (B7), X1.17 (R/!W)
unnamed: IC1.8 (A7), X2.2
unnamed: IC1.7 (A6), X2.4
unnamed: IC1.2 (A1), X2.10
unnamed: IC1.9 (A8), X2.26
unnamed: IC1.3 (A2), X2.27
unnamed: IC1.4 (A3), X2.28
unnamed: X1.3 (BD0), X2.18
unnamed: X1.4 (BD1), X2.19
unnamed: X1.5 (BD2), X2.20
unnamed: IC1.5 (A4), X2.29
unnamed: IC1.6 (A5), X2.30
unnamed: F1.1, IC1.11 (B8), X1.18 (+5VB)
unnamed: X1.1 (!IRQ), X2.8
unnamed: X1.2 (!RST), X2.14

Notes on the sheet:
Do not connect:
Note: D[0..7] requires 2K2 pull up and pull down resistors in order to be at TTL levels. Since BeebSCSI provides terminating resistors, there is no need for them here.
Note: Pin 26 (0V) is used by BeebSCSI to detect if it is connected to the internal bus, so this board provides a logic level 1 on the pin. This board should not be used with ANY other 1 Mhz bus device unless this pin is disconnected.

Board: 2 copper layers, 31.7 x 51.4 mm, 6 parts (0 on the bottom side), 28 nets.

## EAGLE design BeebSCSI_Eagle/BeebSCSI Internal Bus Adapter 1_3.brd

Parts:
C1: 100nF; C0805
F1: SMD1206R500SF; F1812
IC1: 74HC245DW; SO20W
JP1: BBC-MASTER-INT-1MHZ-BUS; MA20-1
JP2: Power out; 1X03
X1: 34-PIN-1MHZ-BUS-FEMALE; FE17-2

Connections:
+5V: C1.1, F1.2, IC1.20 (VCC), JP2.2
GND: C1.2, IC1.1 (DIR), IC1.10 (GND), IC1.19 (G), JP1.20 (0VB), JP2.1, JP2.3, X1.1, X1.3, X1.5, X1.7, X1.9, X1.11, X1.13, X1.15, X1.17, X1.31, X1.32, X1.33, X1.34
unnamed: IC1.11 (B8), JP1.11 (!MODEM)
unnamed: IC1.12 (B7), JP1.12 (A0)
unnamed: IC1.13 (B6), JP1.13 (A1)
unnamed: JP1.6 (BD3), X1.21
unnamed: JP1.7 (BD4), X1.22
unnamed: JP1.8 (BD5), X1.23
unnamed: JP1.9 (BD6), X1.24
unnamed: JP1.10 (BD7), X1.25
unnamed: IC1.14 (B5), JP1.14 (A2)
unnamed: IC1.15 (B4), JP1.15 (A3)
unnamed: IC1.16 (B3), JP1.16 (1MHZE)
unnamed: IC1.17 (B2), JP1.17 (R/!W)
unnamed: IC1.3 (A2), X1.2
unnamed: IC1.4 (A3), X1.4
unnamed: IC1.9 (A8), X1.10
unnamed: IC1.2 (A1), X1.26
unnamed: IC1.8 (A7), X1.27
unnamed: IC1.7 (A6), X1.28
unnamed: JP1.3 (BD0), X1.18
unnamed: JP1.4 (BD1), X1.19
unnamed: JP1.5 (BD2), X1.20
unnamed: IC1.6 (A5), X1.29
unnamed: IC1.5 (A4), X1.30
unnamed: F1.1, IC1.18 (B1), JP1.18 (+5VB)
unnamed: JP1.1 (!IRQ), X1.8
unnamed: JP1.2 (!RST), X1.14

Notes on the sheet:
Do not connect:
Note: D[0..7] requires 2K2 pull up and pull down resistors in order to be at TTL levels. Since BeebSCSI provides terminating resistors, there is no need for them here.
Note: Pin 26 (0V) is used by BeebSCSI to detect if it is connected to the internal bus, so this board provides a logic level 1 on the pin. This board should not be used with ANY other 1 Mhz bus device unless this pin is disconnected.

Board: 2 copper layers, 35.5 x 52.1 mm, 6 parts (1 on the bottom side), 28 nets.

## EAGLE design BeebSCSI_Eagle/BeebSCSI 7_5.brd

Parts:
C1, C2: 22pF; C0805
C3, C4, C5, C6, C7, C8, C9, C10: 100nF; C0805
H1, H2: MOUNT-HOLE2.8; 2,8
IC1: AT90USB1287-AU; TQFP64
JP1: JTAG; 057-010-1
JP2: Serial Debug; 1X06
JP3: JTAG; 1X06
LED1: Status; CHIP-LED0805
R1: 10K; R1206
R2: 470R; R1206
RN1, RN2, RN3, RN4, RN5, RN6: 2K2; SIL9
U1: XC9572XL; VQ64
X1: BUS1; 34-PIN-FLOPPY-CONNECTOR
Y1: 16MHZ; X2-SMD-5.0X3.2X1.3MM

Connections:
+3V3: C7.1, C8.1, C9.1, C10.1, JP3.1, U1.3 (VCCINT1), U1.26 (VCCIO1), U1.37 (VCCINT2), U1.55 (VCCIO2); also elsewhere on the board
+5V: C3.1, C4.1, C6.1, IC1.3 (UVCC), IC1.21 (VCC), IC1.52 (VCC), IC1.64 (AVCC), JP1.4, JP1.7, LED1.A, R1.1, RN1.1, RN2.1, RN5.1; also elsewhere on the board
BBC_1MHZE: RN5.3 (2), RN6.3 (2), U1.15 (P15/GCK1/FB1), X1.4
BBC_!IRQ: U1.13 (P13/FB1), X1.8
BBC_!NMI: X1.6
BBC_!PGFC: RN5.5 (2), RN6.5 (2), U1.12 (P12/FB1), X1.10
BBC_!PGFD: RN5.6 (2), RN6.6 (2), X1.12
BBC_!RESET: U1.11 (P11/FB1), X1.14
BBC_A0: RN1.5 (2), RN3.5 (2), U1.64 (P64/GSR/FB2), X1.27
BBC_A1: RN2.5 (2), RN4.5 (2), U1.63 (P63/FB2), X1.28
BBC_A2: RN1.4 (2), RN3.4 (2), U1.62 (P62/FB2), X1.29
BBC_A3: RN2.4 (2), RN4.4 (2), U1.61 (P61/FB2), X1.30
BBC_A4: RN1.3 (2), RN3.3 (2), U1.60 (P60/FB2), X1.31
BBC_A5: RN2.3 (2), RN4.3 (2), U1.59 (P59/FB2), X1.32
BBC_A6: RN1.2, RN3.2, U1.58 (P58/FB2), X1.33
BBC_A7: RN2.2, RN4.2, U1.57 (P57/FB4), X1.34
BBC_AUDIO_IN: X1.16
BBC_D0: RN5.9 (2), RN6.9 (2), U1.10 (P10/FB1), X1.18
BBC_D1: RN1.9 (2), RN3.9 (2), U1.9 (P9/FB1), X1.19
BBC_D2: RN2.9 (2), RN4.9 (2), U1.8 (P8/FB1), X1.20
BBC_D3: RN1.8 (2), RN3.8 (2), U1.7 (P7/FB2), X1.21
BBC_D4: RN2.8 (2), RN4.8 (2), U1.6 (P6/FB2), X1.22
BBC_D5: RN1.7 (2), RN3.7 (2), U1.5 (P5/GTS1/FB2), X1.23
BBC_D6: RN2.7 (2), RN4.7 (2), U1.4 (P4/FB2), X1.24
BBC_D7: RN1.6 (2), RN3.6 (2), U1.2 (P2/GTS2/FB2), X1.25
BBC_INT/!EXT: RN2.6 (2), RN4.6 (2), U1.1 (P1/FB2), X1.26
BBC_R/!W: RN5.2, RN6.2, U1.16 (P16/GCK2/FB1), X1.2
GND: C1.1, C2.1, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, IC1.6 (UGND), IC1.22 (GND), IC1.53 (GND), IC1.63 (GND), JP1.2, JP1.10, JP2.1, JP3.2, RN3.1, RN4.1, RN6.1, U1.14 (GND1), U1.17 (P17/GCK3/FB1), U1.18 (P18/FB1), U1.19 (P19/FB1), U1.20 (P20/FB1), U1.21 (GND2), U1.22 (P22/FB3), U1.23 (P23/FB1), U1.24 (P24/FB3), U1.25 (P25/FB3), U1.27 (P27/FB3), U1.41 (GND3), U1.51 (P51/FB4), U1.52 (P52/FB4), U1.54 (GND4), U1.56 (P56/FB4), X1.1, X1.3, X1.5, X1.7, X1.9, X1.11, X1.13, X1.15, X1.17; also elsewhere on the board
unnamed: IC1.33 (PE0(/WR)), R2.2
unnamed: LED1.C, R2.1
unnamed: JP3.3, U1.30 (TCK_JTAG)
unnamed: JP3.4, U1.53 (TDO_JTAG)
unnamed: JP3.5, U1.28 (TDI_JTAG)
unnamed: JP3.6, U1.29 (TMS_JTAG)
unnamed: IC1.57 (PF4(ADC4/TCK)), JP1.1
unnamed: IC1.56 (PF5(ADC5/TMS)), JP1.5
unnamed: IC1.55 (PF6(ADC6/TDO)), JP1.3
unnamed: IC1.54 (PF7(ADC7/TDI)), JP1.9
unnamed: C1.2, IC1.23 (XTAL2), Y1.2
unnamed: C2.2, IC1.24 (XTAL1), Y1.1
unnamed: IC1.20 (RESET), JP1.6, R1.2
unnamed: C5.2, IC1.62 (AREF)
unnamed: IC1.27 (PD2(RXD1/INT2)), JP2.4
unnamed: IC1.28 (PD3(TXD1/INT3)), JP2.5
SCSI_!ACK: IC1.42 (PC7(A15/IC.3/CLK0)), U1.40 (P40/FB3)
SCSI_!BSY: IC1.36 (PC1(A9)), U1.47 (P47/FB4)
SCSI_!CONF: IC1.26 (PD1(OC.2B/SDA/INT1)), U1.50 (P50/FB4)
SCSI_!MSG: IC1.35 (PC0(A8)), U1.48 (P48/FB4)
SCSI_!REQ: IC1.37 (PC2(A10)), U1.46 (P46/FB4)
SCSI_!RST: IC1.25 (PD0(OC.0B/SCL/INT0)), U1.49 (P49/FB4)
SCSI_!SEL: IC1.41 (PC6(A14/OC.3A)), U1.42 (P42/FB3)
SCSI_C/!D: IC1.39 (PC4(A12/OC.3C)), U1.44 (P44/FB4)
SCSI_DB0: IC1.51 (PA0(AD0)), U1.31 (P31/FB3)
SCSI_DB1: IC1.50 (PA1(AD1)), U1.32 (P32/FB3)
SCSI_DB2: IC1.49 (PA2(AD2)), U1.33 (P33/FB3)
SCSI_DB3: IC1.48 (PA3(AD3)), U1.34 (P34/FB3)
SCSI_DB4: IC1.47 (PA4(AD4)), U1.35 (P35/FB3)
SCSI_DB5: IC1.46 (PA5(AD5)), U1.36 (P36/FB3)
SCSI_DB6: IC1.45 (PA6(AD6)), U1.38 (P38/FB3)
SCSI_DB7: IC1.44 (PA7(AD7)), U1.39 (P39/FB3)
SCSI_I/!O: IC1.38 (PC3(A11/T.3)), U1.45 (P45/FB4)
SCSI_INT/!EXT: IC1.40 (PC5(A13/OC.3B)), U1.43 (P43/FB4)
SD_CD: IC1.15 (PB5(PCINT5/OC.1A)); also elsewhere on the board
SD_CLK: IC1.11 (PB1(PCINT1/SCK)); also elsewhere on the board
SD_CS0: IC1.10 (PB0(SS/PCINT0)); also elsewhere on the board
SD_MISO: IC1.13 (PB3(PDO/PCINT3/MISO)); also elsewhere on the board
SD_MOSI: IC1.12 (PB2(PDI/PCINT2/MOSI)); also elsewhere on the board
SD_POWER: IC1.14 (PB4(PCINT4/OC.2A)); also elsewhere on the board
UCAP: IC1.7 (UCAP)
VBUS: IC1.8 (VBUS)

Notes on the sheet:
(c) 2016 Simon Inns Licensing (CC BY 4.0) Attribution 4.0 International
BeebSCSI
AVR Decoupling
CPLD Decoupling
Note: Pin 26 on the 1 Mhz bus connector is usually a ground. The CPLD uses this line as a signal to indicate if we are connected to the external or internal bus connector. The adaptor for the internal adaptor should route +5Vs to this pin.

Parts:
C11, C13: 10uF Tant; EIA3528
C12: 1uF; C0805
IC2: 74AHC125S; SO14
IC3: LM1117IMPX-3.3; SOT223
J1: Micro SDcard; MOLEX-SD-503398-003
JP4: 5V in; 1X03
Q1: ZXMP3A13FTA; SOT23-3
R3, R4, R5, R6: 47K; R1206

Connections:
+3V3: C13.A (+), IC3.2 (OUT), Q1.2 (S); also elsewhere on the board
+5V: C11.A (+), IC3.3 (IN), JP4.2, R6.1; also elsewhere on the board
GND: C11.C (-), C12.2, C13.C (-), IC2.1 (OE), IC2.4 (OE), IC2.7 (GND), IC2.10 (OE), IC2.12 (I), IC2.13 (OE), IC3.1 (GND), J1.6 (VSS), J1.DL, J1.SHLD1 (SHLD), J1.SHLD2 (SHLD), J1.SHLD3 (SHLD), J1.SHLD4 (SHLD), JP4.1, JP4.3; also elsewhere on the board
unnamed: IC2.3 (O), J1.2 (DAT3/CD)
unnamed: IC2.6 (O), J1.3 (CMD)
unnamed: IC2.8 (O), J1.5 (CLK)
unnamed: J1.8 (DAT1), R5.2
unnamed: J1.1 (DAT2), R4.2
unnamed: C12.1, IC2.14 (VCC), J1.4 (VDD), Q1.3 (D), R3.1, R4.1, R5.1
SD_CD: J1.DS; also elsewhere on the board
SD_CLK: IC2.9 (I); also elsewhere on the board
SD_CS0: IC2.2 (I); also elsewhere on the board
SD_MISO: J1.7 (DAT0), R3.2; also elsewhere on the board
SD_MOSI: IC2.5 (I); also elsewhere on the board
SD_POWER: Q1.1 (G), R6.2; also elsewhere on the board

Notes on the sheet:
(c) 2016 Simon Inns Licensing (CC BY 4.0) Attribution 4.0 International
BeebSCSI

Board: 2 copper layers, 82.5 x 51.4 mm, 40 parts (25 on the bottom side), 72 nets.

## Code that names these connections

File BeebSCSI_AVR/BeebSCSI_AVR/fatfs/mmc_avr_spi.c (part):

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	if (debugFlag_fatfs) debugString_P(PSTR("FAT FS: power_on(): Initialising SPI and powering up card\r\n"));
	
	/* Configure MOSI/MISO/SCLK/CS pins */
	DDRB |= (1 << PB0);		// Output - CS0
	DDRB |= (1 << PB1);		// Output - CLK
	DDRB |= (1 << PB2);		// Output - MOSI
	DDRB &= ~(1 << PB3);	// Input - MISO
	DDRB |= (1 << PB4);		// Output - Power
	DDRB &= ~(1 << PB5);	// Input - CD
	
	// Enable pull ups on MISO and CD
	PORTB |= (1 << PB3);
	PORTB |= (1 << PB5);
	
	/* Turn socket power on */
	PORTB &= ~_BV(4);
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	SPCR = 0;

	/* De-configure MOSI/MISO/SCLK/CS pins (set hi-z) */
	DDRB &= ~(1 << PB0);		// Input - CS0
	DDRB &= ~(1 << PB1);		// Input - CLK
	DDRB &= ~(1 << PB2);		// Input - MOSI
	DDRB &= ~(1 << PB3);		// Input - MISO
	
	// Disable pull ups on MISO and CD
	PORTB &= ~(1 << PB3);
	PORTB &= ~(1 << PB5);

	/* Turn socket power off  */
	PORTB |= _BV(4);
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
## Commit log

2017-01-07 :tada: Added .gitattributes
2017-01-07 Initial commit
    Initial commit of BeebSCSI to GitHub
2017-01-07 Initial push of the BBC Master internal bus adapter board and schematic
    Initial push of the BBC Master internal bus adapter board and schematic
2017-01-08 Corrected README files
    Corrected README files
2017-01-11 Fixed bugs in F-Code handling
    Removed interrupt disable when sending/receiving F-Codes over SCSI
    (interrupt disable was causing serial bytes to be lost - and VFS is
    slower than ADFS, so interrupts do not effect the DMA transfer). Added
    additional check to the F-code handling function to ensure that a
    complete CR terminated F-Code response is received from the serial port
    before transfering to host via SCSI.
2017-01-19 Added SD Card Bootloader
    This update adds a SD Card based bootloader to the AVR allowing BeebSCSI
    to be flashed without the need for an AVR programmer. The BeebSCSI_AVR
    project file (for Atmel Studio 7) has also been updated so that it
    produces the required BEEBSCSI.BIN file. Note: The bootloader will
    only work with FAT16 and FAT32 compatible SD cards (i.e. typically 32Gb
    or less).
2017-01-22 Enhancements to DMA transfer debug
    Some minor enhancements to the debug output around the DMA transfer.
    The debug now reports how many bytes were received before DMA transfer
    failure. The DMA read and write routines have also been changed
    slightly to increase execution speed.
2017-02-01 Added new ROM for the BBC Master and Micro - plus enhanced BeebSCSI firmware to support the ROM
    BeebSCSI now implements two additional SCSI G6 (vendor specific)
    commands that allow the ROM to get the status of BeebSCSI and perform
    "Jukeboxing". Since ADFS only allows 4 LUNs at any one time, BeebSCSI
    allows the user to 'jukebox' the LUNs and have up to 256 sets of LUNs (a
    set of LUNs being 4 under ADFS or 8 under VFS).
    Jukeboxing allows BeebSCSI to provide up to 512 Gbytes of storage to
2017-02-02 Bug fixes and enhancements to BeebSCSI_ROM
    Fixed bug in ROM header and improved filing system detection code in the
    BeebSCSI ROM
2017-02-02 Bug fixes to filing system detection in BeebSCSI ROM
    Minor bug fixes to BeebSCSI ROM
2017-02-02 Implemented error handling and better OSWORD block code
    Implemented error handling. Changed OSWORD code to use predefined
    blocks (for code neatness) and fixed some minor bugs.
2017-02-02 Updated error handing to use correct error numbers
    Updated error handing to use correct error numbers and adjusted comments
    to be more accurate about error handling process.
2017-02-03 Minor changes to bootloader
    Fixed the bootloader main.c header (it had the incorrect module
    information)
2017-02-03 Fixed bug in ROM error handler
    Minor bug in the ROM error handler that could cause bad error messages
    (out by one error)
2017-02-04 Updated internal adapter board
    Updated internal adapter board design. The design has been changed to
    be more simple to make without the requirement for SIL cabling.
2017-02-04 Minor fixes for BBC Micro
    Added additional workspace claims as a precaution on BBC Micros. Also
    modified the IDE project file for cleaner loading in BeebEm during
    development
2017-10-01 Fixed timing bug in ttl74573 module
    Fixed timing bug in ttl74573 module
2017-10-01 Added *.htm
    Added *.htm
2017-10-01 Switch status register back to positive edge latching
    Switch status register back to positive edge latching
2018-03-18 Updated headers. Parital fix for issue #2
    Updated code headers to 2018.
    Added partial fix for issue #2 - Read6 and Write6 commands to a STOPped LUN will now auto-start the LUN (if the LUN image is available on the SD card). This does not fix the 'not found' issue.
    Debug turned on by default (for development) and reported version number bumped to V002.001.
2018-03-18 Fixed the bootloader to compile correctly in release mode #3
2018-03-18 Fixed AVR firmware to correctly compile in release mode #3
2018-03-18 Added generation of BEEBSCSI.BIN (bootloader programming file) to release configuration
2018-03-18 Update to release candidate - ready for testing
2018-03-18 Minor fix to AVR debug output
2018-03-18 Added initial code for supporting additional vendor specific commands
    Added initial code for 3 new vendor specific SCSI codes. Modified debug to change default debug output to 'on' when compiling in debug config and 'off' when compiling in release config.
2018-03-19 Added BSFATINFO and BSFATREAD G6 commands - basic command handling only
    Added two new G6 commands to test passing of custom buffers (containing file data and file information) between BeebSCSI and the host. Actual file handing functionality is not yet implemented.
2018-03-20 Added additional debug option and BSFATINFO command implemented
    Added additional debug option for tracing FAT transfer operations
    BSFATINFO command implemented - now transfers object type, object size and file name to host
2018-03-21 Added multi-block reading to the FAT handling
    Additional structural changes ready for the FAT file data transfer operations
2018-03-21 Initial working implementation of BSFATREAD command
    Command is now working, but it is very heavy on the FAT FS interaction. Needs to be stateful during multi-block transfer to speed up the overall transfer speed to the host.
    Also added hex dump code to the BSFATINFO command to allow debug on the file information data
2018-03-23 Bug fix to BSFATREAD command
2018-03-24 FAT information and file reading now fully implemented and ready for testing
    Improved overall structure and increased the efficiency of the FAT filling commands. Restructured debug to match new FAT implementation. Merged old fat.c functionality into the filesystem layer (and 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
2018-03-24 Added command to allow change of FAT transfer directory
2018-03-25 Added BeebSCSI FAT transfer utility and updated readme files
2018-03-25 Added ADL floppy image of BSTrans
2018-03-25 Fix to ROM image due to issue #5
    BeebSCSI ROM was not passing unprocessed commands to lower priority ROMs; also, in some *ROM listings, the version number was being displayed twice (this is more of a bug in the ROM listing utilities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
2018-03-25 Updated ROM help strings, fixed readme and included .rom image in github
    Final fixes for #5
2018-03-25 Additional bug fix to ROM, bumped version to 1.04
2018-05-01 Added new 7_6 PCB design
    The new 7_6 PCB design is now in KiCAD format. The following improvements have been made:
    Smaller PCB
    Clearer silkscreen layout
    4 Mounting holes for mounting in a 3D printed case
    New MicroSD card holder - card now extends over board edge for case mounting
    5V connector is JST-EH to prevent reverse connection
2018-05-01 Added new KiCAD design for the VFS adapter board
    Also updated readme and included title information in the 7_5 PCB design files
2018-05-01 Adding git ignore files to KiCAD projects
2018-05-01 Removed kicad tmp files
2018-05-01 Added fiducials for pick and place alignment
2018-05-01 Added fiducials to VFS board for easier pick and place
2018-05-01 Added protection diode to VFS adapter and updated all PDF copies
2018-05-01 Added license files for KiCAD design
2018-05-02 Interim check in of new PCB update
2018-05-03 Interim check in of board design - added back silkscreen items
2018-05-03 Finalised BeebSCSI board including USB header
2018-05-03 Finialised VFS adapter PCB
2018-05-03 Corrected version number in readme file
2018-05-06 Added design for a cartridge adaptor (prototype only)
2018-05-06 Added jpeg of cartridge adapter
2018-05-07 Added missing solder mask Gerbers to cartridge adapter
2018-05-18 Updated 7_7 Board version
    Fixes for issues #12 #11 #10 #9
    Improved silkscreen
2018-05-19 Additional changes to BeebSCSI 7_7 PCB
    Added additional grounding to CPLD. Changed EXT/INT pull-up to 2K2.
    Modified CPLD programming to set unused pins to ground and added JTAG daisy-chain configuration to device programming.
2018-05-19 Redesigned cartridge adaptor and added dual EPROM sockets plus required hardware
    Fixes issues #15 and #14
2018-05-19 Remove files accidentally included
    ISE studio seems to put it's temporary files wherever it likes...
2018-05-26 Remove old 7_5 Eagle CAD revision of schematic and board design
2018-05-26 Fix for issue #13 - Added additional (and non-optional) start up debug. Also included emulation mode and firmware version in debug output
2018-05-26 Cleaned up debug output and added USB capable board detection. Modified status LED functions ready for additional functionality
2018-05-27 Enhanced status LED control to fix #8
    Status LED is now PWM controlled. When power on the LED lights with minimum brightness. Activity now causes the LED to show maximum brightness followed by a .25 second fade out.
2018-08-02 Initial commit of 3D printable case
    Original OpenSCAD files and output STL files included. Case requires straight power connector and right-angle IDC.
2018-08-02 Modifications and corrections
    Increased logo size on upper case (smaller holes did not print well).
    Added option to remove upper case logo
    Corrected text depth on lower case
2018-08-02 Updated STL models
2018-08-02 Updated readme file
2018-08-03 Fix to centre logo correctly on upper case
2018-08-03 Included vents in lower case to save printing time
2018-08-03 Corrected logo bitmap
2018-12-08 Update ff.h
    Make definition match usage
2019-02-21 Fix transfer of files longer that a single block.
    If a file had a length of say (512 bytes +31 ) the actual transfered file would end up with 512 byte + 31 bytes of junk + 31 real bytes.
    Almost certainly a better way of fixing this.
2019-02-21 Fix File transfer as they would have extra bytes inserted
    If a file had a length of say (512 bytes +31 ) the actual transfered file would end up with 512 byte + 31 bytes of junk + 31 real bytes.
2019-03-04 filesystem.c: changed to leave scsixx.dat open as long as possible
    Leaving scsixx.dat open as long as possible and setting up FASTSEEK. This improves performance for sectors access at the end of scsixx.dat. For sectors at the end of scsixx.dat these changes save 127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
2019-03-23 Updated headers, versioning and modified filesystem.c
2019-03-23 Code style update
2019-03-24 Updated BSTrans for firmware 2.5
    Created new BASIC image and imported into ADL file for use with floppy emulation
2019-03-24 FIx for issue #20
2019-03-24 Minor fix to filesystem.c logic
2019-03-24 Bug fix and some enhancements
    Bug fix to filesystemOpenLunForRead to make it more intelligent when handling LUN changes. Added additional flush debug to make it easier to trace what's causing the flush. Fixed debug output in scsi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
2020-02-08 Fix for issues #23 and #24 and updated headers
2020-02-08 Upgraded FAT library to R0.14 issue #25 - improved LUN handling debug
2020-04-17 Add new 3D printable case design
2020-04-17 Fixed readme png link
2022-12-19 Changed readme and included quick-start LUN image into main repo

Notices in the files:
BeebSCSI_AVR/BeebSCSI_AVR/fatfs/mmc_avr_spi.c:
Copyright (C) 2016, ChaN, all right reserved.
BeebSCSI_Eagle/BeebSCSI 7_5.brd:
(c)2017 Simon inns
parts and their libraries:
SparkFun-Passives: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
