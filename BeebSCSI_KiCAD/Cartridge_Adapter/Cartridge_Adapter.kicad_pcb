# Repository simoninns/BeebSCSI

File README.md:

## Synopsis

BeebSCSI is a Micro SD Card based SCSI storage emulation for the Acorn 8-bit range of microcomputers including the Acorn BBC Model B (with ADFS) and the BBC Master 128.

Please see [the project wiki](https://github.com/simoninns/BeebSCSI/wiki) for detailed documentation on BeebSCSI

The project is divided into several sections:

BeebSCSI_AVR - This is the AT90USB1287 microcontroller firmware (written in GCC)

BeebSCSI_CPLD - This is the Xilinx XC9572XL CPLD firmware (written in ISE Verilog)

BeebSCSI_KiCAD - This folder contains the KiCAD schematics and PCB designed (V7_6 and above)

BeebSCSI_OpenSCAD - This folder contains a 3D printable case designed in OpenSCAD

BeebSCSI_ROM - This folder contains the 6502 assembly code for the BeebSCSI ROM

BeebSCSI_Utils - This folder contains BBC BASIC utilities for BeebSCSI

## Motivation

Originally Acorn provided a SCSI solution based on 3 individual parts: The Acorn SCSI host adapter, the Adaptec ACB-4000 SCSI adapter and a physical MFM hard disc (a ‘Winchester drive’). Later, as part of the Domesday project (in 1986), this was extended to include the AIV SCSI Host Adapter (designed to be connected internally to a BBC Master Turbo) and the Philips VP415 LaserVision laser disc player with SCSI-1 support.

BeebSCSI 7 is a credit-card sized board that provides a single-chip implementation of the host adapter board (both original and AIV) using a modern CPLD (Complex Programmable Logic Device). In addition, an AVR Microcontroller provides a complete SCSI-1 emulation including the vendor specific video control commands of the VP415.

Rather than using a physical hard drive, BeebSCSI uses a single Micro SD card to provide up to >64Gbytes of storage with support for either 4 (ADFS) or 8 (VFS) virtual hard drives (or ‘LUNs’) per card. In addition, in the BBC Master, two BeebSCSI devices can be attached, one internal and one external, providing 12 SCSI LUNs (hard drive images) simultaneously.

## Installation

Please see http://www.domesday86.com for detailed documentation on BeebSCSI

## Author

BeebSCSI is written and maintained by Simon Inns.

## Software License (GPLv3)

    BeebSCSI is free software: you can redistribute it and/or modify
    it under the terms of the GNU General Public License as published by
    the Free Software Foundation, either version 3 of the License, or
    (at your option) any later version.

    BeebSCSI is distributed in the hope that it will be useful,
    but WITHOUT ANY WARRANTY; without even the implied warranty of
    MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
    GNU General Public License for more details.

    You should have received a copy of the GNU General Public License
    along with BeebSCSI.  If not, see <http://www.gnu.org/licenses/>.
    
## Hardware License (Creative Commons BY-SA 4.0)

Please see the following link for details: https://creativecommons.org/licenses/by-sa/4.0/

You are free to:

Share - copy and redistribute the material in any medium or format
Adapt - remix, transform, and build upon the material
for any purpose, even commercially.

This license is acceptable for Free Cultural Works.

The licensor cannot revoke these freedoms as long as you follow the license terms.

Under the following terms:

Attribution - You must give appropriate credit, provide a link to the license, and indicate if changes were made. You may do so in any reasonable manner, but not in any way that suggests the licensor endorses you or your use.

ShareAlike - If you remix, transform, or build upon the material, you must distribute your contributions under the same license as the original.

No additional restrictions - You may not apply legal terms or technological measures that legally restrict others from doing anything the license permits.

## KiCad design BeebSCSI_KiCAD/Cartridge_Adapter/Cartridge_Adapter.kicad_pcb

Parts:
C1, C2, C3, C4: 100nF; C_0805
J1: USB_A; Amphenol_87583-2010BLF
J2: 2 MHz Bus; Socket_Strip_Straight_2x17_Pitch2.54mm
J3: USB; JST_EH_B04B-EH-A_04x2.50mm_Straight
J4: AcornCartridgeEdgeConnector; Acorn_Cartridge
J5: 5V out; JST_EH_B02B-EH-A_02x2.50mm_Straight
MK1, MK2, MK3, MK4: Mounting_Hole; MountingHole_3.2mm_M3
U1: 74HCT139; SO-16-N
U2, U3: 27C128; DIP-28_W15.24mm

Connections:
2MHZE: J2.4, J4.8A (PHI2)
+5V: C1.1, C2.1, C3.1, C4.1, J4.1A (+5V), J4.1B (+5V), J5.1, U1.16 (VCC), U2.1 (VPP), U2.28 (VCC), U3.1 (VPP), U3.28 (VCC)
A0: J2.27, J4.18B (BA0), U2.10 (A0), U3.10 (A0)
A1: J2.28, J4.17B (BA1), U2.9 (A1), U3.9 (A1)
A2: J2.29, J4.16B (BA2), U2.8 (A2), U3.8 (A2)
A3: J2.30, J4.15B (BA3), U2.7 (A3), U3.7 (A3)
A4: J2.31, J4.14B (BA4), U2.6 (A4), U3.6 (A4)
A5: J2.32, J4.13B (BA5), U2.5 (A5), U3.5 (A5)
A6: J2.33, J4.12B (BA6), U2.4 (A6), U3.4 (A6)
A7: J2.34, J4.11B (BA7), U2.3 (A7), U3.3 (A7)
A8: J4.5A (A8), U2.25 (A8), U3.25 (A8)
A9: J4.5B (A9), U2.24 (A9), U3.24 (A9)
A10: J4.2B (A10), U2.21 (A10), U3.21 (A10)
A11: J4.4B (A11), U2.23 (A11), U3.23 (A11)
A12: J4.7A (A12), U2.2 (A12), U3.2 (A12)
A13: J4.6A (A13), U2.26 (A13), U3.26 (A13)
ADIN: J2.16, J4.21A (ADIN/SPEECH)
CS_R/~W: J4.4A (CS_R/~W), U1.3 (A1)
D0: J2.18, J4.19B (D0), U2.11 (D0), U3.11 (D0)
D1: J2.19, J4.21B (D1), U2.12 (D1), U3.12 (D1)
D2: J2.20, J4.20B (D2), U2.13 (D2), U3.13 (D2)
D3: J2.21, J4.3B (D3), U2.15 (D3), U3.15 (D3)
D4: J2.22, J4.9B (D4), U2.16 (D4), U3.16 (D4)
D5: J2.23, J4.8B (D5), U2.17 (D5), U3.17 (D5)
D6: J2.24, J4.7B (D6), U2.18 (D6), U3.18 (D6)
D7: J2.25, J4.6B (D7), U2.19 (D7), U3.19 (D7)
GND: C1.2, C2.2, C3.2, C4.2, J1.4 (GND), J1.5 (Shield), J2.1, J2.3, J2.5, J2.7, J2.9, J2.11, J2.13, J2.15, J2.17, J2.26, J3.4, J4.22A (0V), J4.22B (0V), J5.2, U1.1 (E), U1.8 (GND), U1.13 (A1), U2.14 (GND), U3.14 (GND)
NIRQ: J2.8, J4.13A (~IRQ)
NNMI: J2.6, J4.12A (~NMI)
NPGFC: J2.10, J4.14A (~PGFC)
NPGFD: J2.12, J4.15A (~PGFD)
unnamed: J1.1 (VBUS), J3.1
unnamed: J1.2 (D-), J3.2
unnamed: J1.3 (D+), J3.3
unnamed: U1.6 (O2), U2.20 (CE)
unnamed: U1.7 (O3), U3.20 (CE)
unnamed: U1.11 (O1), U2.22 (OE), U3.22 (OE)
unnamed: U1.12 (O0), U2.27 (~PGM), U3.27 (~PGM)
R/~W: J2.2, J4.11A (R/~W~_~RDY), U1.14 (A0)
ROM_~OE: J4.2A (ROM_~OE), U1.15 (E)
ROM_~QA: J4.16A (ROM_~QA), U1.2 (A0)
RST: J2.14, J4.3A (~RST)

Notes on the sheet:
VBus D- D+ GND

Board: 2 copper layers, 81.3 x 104.4 mm, 16 parts (2 on the bottom side), 42 nets.

## KiCad design BeebSCSI_KiCAD/BeebSCSI_Board/BeebSCSI.kicad_pcb

Parts:
C1, C2: 10uF Tant; CP_Tantalum_Case-B_EIA-3528-21_Reflow
F1, F2, F3: Fiducial; Fiducial_0.5mm_Dia_1mm_Outer
J1: 5V Power; JST_EH_B02B-EH-A_02x2.50mm_Straight
J3: JTAG-IDC; Pin_Header_Straight_2x05_Pitch2.54mm
J4: JTAG-TC; Tag-Connect_TC2050-IDC-NL
MK1, MK2, MK3, MK4: Mounting_Hole; MountingHole_3.2mm_M3
U1: LM1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C2.1, J3.4, J4.4, U1.2 (VO); also elsewhere on the board
+5V: C1.1, J1.1, U1.3 (VI); also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_RST: J3.6, J4.6; also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_TCK: J3.1, J4.1; also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_TDI: J3.9, J4.9; also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_TMS: J3.5, J4.5; also elsewhere on the board
/SCSI Host Adapter/CPLD_JTAG_TDO: J3.3, J4.3; also elsewhere on the board
GND: C1.2, C2.2, J1.2, J3.2, J3.10, J4.2, J4.10, U1.1 (GND); also elsewhere on the board

Notes on the sheet:
Power Supply
Vref
TCK
TDO
TMS
TDI
RST

Parts:
J2: BBC 1 MHz Bus; Multicomp_MC9A12-3434_2x17x2.54mm_Straight
R1: 2K2; R_0805
RN1, RN2, RN3, RN4, RN5, RN6, RN7, RN8, RN9, RN10: 2K2; R_Array_Convex_4x0603

Connections:
+5V: R1.1, RN2.5 (R4.2), RN2.6 (R3.2), RN2.7 (R2.2), RN2.8 (R1.2), RN4.5 (R4.2), RN4.6 (R3.2), RN4.7 (R2.2), RN4.8 (R1.2), RN6.5 (R4.2), RN6.6 (R3.2), RN6.7 (R2.2), RN6.8 (R1.2), RN8.5 (R4.2), RN8.6 (R3.2), RN8.7 (R2.2), RN8.8 (R1.2), RN10.5 (R4.2), RN10.6 (R3.2), RN10.7 (R2.2), RN10.8 (R1.2); also elsewhere on the board
/1MHz_Bus/BBC_1MHZE: J2.4, RN9.3 (R3.1), RN10.2 (R2.1); also elsewhere on the board
/1MHz_Bus/BBC_A0: J2.27, RN1.4 (R4.1), RN2.1 (R1.1); also elsewhere on the board
/1MHz_Bus/BBC_A1: J2.28, RN1.3 (R3.1), RN2.2 (R2.1); also elsewhere on the board
/1MHz_Bus/BBC_A2: J2.29, RN1.2 (R2.1), RN2.3 (R3.1); also elsewhere on the board
/1MHz_Bus/BBC_A3: J2.30, RN1.1 (R1.1), RN2.4 (R4.1); also elsewhere on the board
/1MHz_Bus/BBC_A4: J2.31, RN3.4 (R4.1), RN4.1 (R1.1); also elsewhere on the board
/1MHz_Bus/BBC_A5: J2.32, RN3.3 (R3.1), RN4.2 (R2.1); also elsewhere on the board
/1MHz_Bus/BBC_A6: J2.33, RN3.2 (R2.1), RN4.3 (R3.1); also elsewhere on the board
/1MHz_Bus/BBC_A7: J2.34, RN3.1 (R1.1), RN4.4 (R4.1); also elsewhere on the board
/1MHz_Bus/BBC_D0: J2.18, RN5.4 (R4.1), RN6.1 (R1.1); also elsewhere on the board
/1MHz_Bus/BBC_D1: J2.19, RN5.3 (R3.1), RN6.2 (R2.1); also elsewhere on the board
/1MHz_Bus/BBC_D2: J2.20, RN5.2 (R2.1), RN6.3 (R3.1); also elsewhere on the board
/1MHz_Bus/BBC_D3: J2.21, RN5.1 (R1.1), RN6.4 (R4.1); also elsewhere on the board
/1MHz_Bus/BBC_D4: J2.22, RN7.4 (R4.1), RN8.1 (R1.1); also elsewhere on the board
/1MHz_Bus/BBC_D5: J2.23, RN7.3 (R3.1), RN8.2 (R2.1); also elsewhere on the board
/1MHz_Bus/BBC_D6: J2.24, RN7.2 (R2.1), RN8.3 (R3.1); also elsewhere on the board
/1MHz_Bus/BBC_D7: J2.25, RN7.1 (R1.1), RN8.4 (R4.1); also elsewhere on the board
/1MHz_Bus/BBC_INT/~EXT: J2.26, R1.2; also elsewhere on the board
/1MHz_Bus/BBC_R/~W: J2.2, RN9.4 (R4.1), RN10.1 (R1.1); also elsewhere on the board
/1MHz_Bus/BBC_~IRQ: J2.8; also elsewhere on the board
/1MHz_Bus/BBC_~PGFC: J2.10, RN9.2 (R2.1), RN10.3 (R3.1); also elsewhere on the board
/1MHz_Bus/BBC_~RESET: J2.14; also elsewhere on the board
/1MHz_Bus/~PGFD: J2.12, RN9.1 (R1.1), RN10.4 (R4.1)
GND: J2.1, J2.3, J2.5, J2.7, J2.9, J2.11, J2.13, J2.15, J2.17, RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), RN3.5 (R4.2), RN3.6 (R3.2), RN3.7 (R2.2), RN3.8 (R1.2), RN5.5 (R4.2), RN5.6 (R3.2), RN5.7 (R2.2), RN5.8 (R1.2), RN7.5 (R4.2), RN7.6 (R3.2), RN7.7 (R2.2), RN7.8 (R1.2), RN9.5 (R4.2), RN9.6 (R3.2), RN9.7 (R2.2), RN9.8 (R1.2); also elsewhere on the board

Parts:
C3, C4, C5, C6: 100nF; C_0805
U2: XC9572XL; TQFP-64_10x10mm_Pitch0.5mm

Connections:
+3V3: C3.1, C4.1, C5.1, C6.1, U2.3 (VCCINT1), U2.26 (VCCIO1), U2.37 (VCCINT2), U2.55 (VCCIO2); also elsewhere on the board
/1MHz_Bus/BBC_1MHZE: U2.15 (P15/GCK1/FB1); also elsewhere on the board
/1MHz_Bus/BBC_A0: U2.64 (P64/GSR/FB2); also elsewhere on the board
/1MHz_Bus/BBC_A1: U2.63 (P63/FB2); also elsewhere on the board
/1MHz_Bus/BBC_A2: U2.62 (P62/FB2); also elsewhere on the board
/1MHz_Bus/BBC_A3: U2.61 (P61/FB2); also elsewhere on the board
/1MHz_Bus/BBC_A4: U2.60 (P60/FB2); also elsewhere on the board
/1MHz_Bus/BBC_A5: U2.59 (P59/FB2); also elsewhere on the board
/1MHz_Bus/BBC_A6: U2.58 (P58/FB2); also elsewhere on the board
/1MHz_Bus/BBC_A7: U2.57 (P57/FB4); also elsewhere on the board
/1MHz_Bus/BBC_D0: U2.10 (P10/FB1); also elsewhere on the board
/1MHz_Bus/BBC_D1: U2.9 (P9/FB1); also elsewhere on the board
/1MHz_Bus/BBC_D2: U2.8 (P8/FB1); also elsewhere on the board
/1MHz_Bus/BBC_D3: U2.7 (P7/FB2); also elsewhere on the board
/1MHz_Bus/BBC_D4: U2.6 (P6/FB2); also elsewhere on the board
/1MHz_Bus/BBC_D5: U2.5 (P5/GTS1/FB2); also elsewhere on the board
/1MHz_Bus/BBC_D6: U2.4 (P4/FB2); also elsewhere on the board
/1MHz_Bus/BBC_D7: U2.2 (P2/GTS2/FB2); also elsewhere on the board
/1MHz_Bus/BBC_INT/~EXT: U2.1 (P1/FB2); also elsewhere on the board
/1MHz_Bus/BBC_R/~W: U2.16 (P16/GCK2/FB1); also elsewhere on the board
/1MHz_Bus/BBC_~IRQ: U2.13 (P13/FB1); also elsewhere on the board
/1MHz_Bus/BBC_~PGFC: U2.12 (P12/FB1); also elsewhere on the board
/1MHz_Bus/BBC_~RESET: U2.11 (P11/FB1); also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_TCK: U2.30 (TCK_JTAG); also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_TDO: U2.28 (TDI_JTAG); also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_TMS: U2.29 (TMS_JTAG); also elsewhere on the board
/SCSI Drive Emulator/SCSI_C/~D: U2.44 (P44/FB4); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D0: U2.31 (P31/FB3); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D1: U2.32 (P32/FB3); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D2: U2.33 (P33/FB3); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D3: U2.34 (P34/FB3); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D4: U2.35 (P35/FB3); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D5: U2.36 (P36/FB3); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D6: U2.38 (P38/FB3); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D7: U2.39 (P39/FB3); also elsewhere on the board
/SCSI Drive Emulator/SCSI_I/~O: U2.45 (P45/FB4); also elsewhere on the board
/SCSI Drive Emulator/SCSI_INT/~EXT: U2.43 (P43/FB4); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~ACK: U2.40 (P40/FB3); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~BSY: U2.47 (P47/FB4); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~CONF: U2.50 (P50/FB4); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~MSG: U2.48 (P48/FB4); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~REQ: U2.46 (P46/FB4); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~RST: U2.49 (F49/FB4); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~SEL: U2.42 (P42/FB3); also elsewhere on the board
/SCSI Host Adapter/CPLD_JTAG_TDO: U2.53 (TDO_JTAG); also elsewhere on the board
GND: C3.2, C4.2, C5.2, C6.2, U2.14 (GND), U2.17 (P17/GCK3/FB1), U2.18 (P18/FB1), U2.19 (P19/FB1), U2.20 (P20/FB1), U2.21 (GND), U2.22 (P22/FB3), U2.23 (P23/FB1), U2.24 (P24/FB3), U2.25 (P25/FB3), U2.27 (P27/FB3), U2.41 (GND), U2.51 (P51/FB4), U2.52 (P52/FB4), U2.54 (GND), U2.56 (P56/FB4); also elsewhere on the board

Parts:
C7, C8, C9, C12: 100nF; C_0805
C10, C11: 22pF; C_0805
C14: 1uF; C_0805
D1: Status LED; LED_0805
IC1: AT90USB1287; TQFP-64_14x14mm_Pitch0.8mm
J5: TTL Serial; Pin_Header_Straight_1x06_Pitch2.54mm
J7: USB; JST_EH_B04B-EH-A_04x2.50mm_Straight
R2: 470R; R_0805
R3, R10: 10K; R_0805
R8, R9: 22R; R_0805
Y1: 16MHz Crystal; Crystal_SMD_5032-2pin_5.0x3.2mm

Connections:
+5V: C7.1, C8.1, C9.1, D1.2 (A), IC1.3 (UVcc), IC1.8 (VBus), IC1.21 (Vcc), IC1.52 (Vcc), IC1.64 (AVcc), J7.1, R3.1; also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_RST: IC1.20 (~RESET), R3.2; also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_TCK: IC1.57 ((ADC4/TCK)PF4); also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_TDI: IC1.54 ((ADC7/TDI)PF7); also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_TDO: IC1.55 ((ADC6/TDO)PF6); also elsewhere on the board
/SCSI Drive Emulator/AVR_JTAG_TMS: IC1.56 ((ADC5/TMS)PF5); also elsewhere on the board
/SCSI Drive Emulator/SCSI_C/~D: IC1.39 ((A12/OC.3C)PC4); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D0: IC1.51 ((AD0)PA0); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D1: IC1.50 ((AD1)PA1); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D2: IC1.49 ((AD2)PA2); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D3: IC1.48 ((AD3)PA3); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D4: IC1.47 ((AD4)PA4); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D5: IC1.46 ((AD5)PA5); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D6: IC1.45 ((AD6)PA6); also elsewhere on the board
/SCSI Drive Emulator/SCSI_D7: IC1.44 ((AD7)PA7); also elsewhere on the board
/SCSI Drive Emulator/SCSI_I/~O: IC1.38 ((A11/T.3)PC3); also elsewhere on the board
/SCSI Drive Emulator/SCSI_INT/~EXT: IC1.40 ((A13/OC.3B)PC5); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~ACK: IC1.42 ((A15/IC.3/CLKO)PC7); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~BSY: IC1.36 ((A9)PC1); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~CONF: IC1.26 ((OC2B/SDA/INT1)PD1); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~MSG: IC1.35 ((A8)PC0); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~REQ: IC1.37 ((A10)PC2); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~RST: IC1.25 ((OC0B/SCL/INT0)PD0); also elsewhere on the board
/SCSI Drive Emulator/SCSI_~SEL: IC1.41 ((A14/OC.3A)PC6); also elsewhere on the board
/SCSI Drive Emulator/SDCARD_CD: IC1.15 ((PCINT5/OC.1A)PB5); also elsewhere on the board
/SCSI Drive Emulator/SDCARD_CLK: IC1.11 ((PCINT1/SCLK)PB1); also elsewhere on the board
/SCSI Drive Emulator/SDCARD_CS0: IC1.10 ((SS/PCINT0)PB0); also elsewhere on the board
/SCSI Drive Emulator/SDCARD_MISO: IC1.13 ((PDO/PCINT3/MISO)PB3); also elsewhere on the board
/SCSI Drive Emulator/SDCARD_MOSI: IC1.12 ((PDI/PCINT2/MOSI)PB2); also elsewhere on the board
/SCSI Drive Emulator/SDCARD_POWER: IC1.14 ((PCINT4/OC.2A)PB4); also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, IC1.6 (UGnd), IC1.22 (Gnd), IC1.53 (Gnd), IC1.63 (Gnd), J5.1, J7.4, R10.2; also elsewhere on the board
unnamed: C10.1, IC1.24 (Xtal1), Y1.1
unnamed: C11.1, IC1.23 (Xtal2), Y1.2
unnamed: C12.1, IC1.62 (ARef)
unnamed: C14.1, IC1.7 (UCap)
unnamed: D1.1 (K), R2.2
unnamed: IC1.4 (D-), R8.1
unnamed: IC1.5 (D+), R9.1
unnamed: IC1.27 ((RXD1/INT2)PD2), J5.4
unnamed: IC1.28 ((TXD1/INT3)PD3), J5.5
unnamed: IC1.33 ((~WR~)PE0), R2.1
unnamed: IC1.58 ((ADC3)PF3), R10.1
unnamed: J7.2, R8.2
unnamed: J7.3, R9.2

Notes on the sheet:
VBus
GND
Note: R10 indicates available USB hardware to the firmware

Parts:
C13: 1uF; C_0805
J6: Micro_SD_Card_Det; microSD_Holder_Molex-47309-3751
Q1: ZXMP3A13FTA; SOT-23
R4, R5, R6, R7: 47K; R_0805
U3: 74AHC125S; SOIC-14_N

Connections:
+3V3: Q1.2 (S); also elsewhere on the board
+5V: R7.1; also elsewhere on the board
/SCSI Drive Emulator/SDCARD_CD: J6.10 (DET_A); also elsewhere on the board
/SCSI Drive Emulator/SDCARD_CLK: U3.9 (D); also elsewhere on the board
/SCSI Drive Emulator/SDCARD_CS0: U3.2 (D); also elsewhere on the board
/SCSI Drive Emulator/SDCARD_MISO: J6.7 (DAT0), R4.2; also elsewhere on the board
/SCSI Drive Emulator/SDCARD_MOSI: U3.5 (D); also elsewhere on the board
/SCSI Drive Emulator/SDCARD_POWER: Q1.1 (G), R7.2; also elsewhere on the board
GND: C13.2, J6.6 (VSS), J6.9 (DET_B), J6.11 (SHIELD), U3.1 (E), U3.4 (E), U3.7 (GND), U3.10 (E), U3.12 (D), U3.13 (E); also elsewhere on the board
unnamed: J6.1 (DAT2), R6.2
unnamed: J6.2 (DAT3/CD), U3.3 (O)
unnamed: J6.3 (CMD), U3.6 (O)
unnamed: J6.5 (CLK), U3.8 (O)
unnamed: J6.8 (DAT1), R5.2
VCC: C13.1, J6.4 (VDD), Q1.3 (D), R4.1, R5.1, R6.1, U3.14 (VCC)

Notes on the sheet:
Note: Vcc is the 3V3 input to the 74AHC125S which is turned on and off by SDCARD_POWER via the MOSFET

Notices in the files:
BeebSCSI_AVR/BeebSCSI_AVR/fatfs/mmc_avr_spi.c:
Copyright (C) 2016, ChaN, all right reserved.
BeebSCSI_KiCAD/BeebSCSI_Board/BeebSCSI.kicad_pcb:
(c)2018 Simon Inns
License: Attribution-ShareAlike 4.0 International (CC BY-SA 4.0)
BeebSCSI_KiCAD/Cartridge_Adapter/Cartridge_Adapter.kicad_pcb:
License: Attribution ShareAlike International (CC BY-SA 4.0)
BeebSCSI_KiCAD/VFS_Adapter/VFS_Adapter.kicad_pcb:
(c)2018 Simon Inns (CC BY-SA 4.0)
