# Repository simoninns/BeebSCSI (continued)

## KiCad design BeebSCSI_KiCAD/BeebSCSI_Board/BeebSCSI.kicad_pcb (continued)

Board: 2 copper layers, 65.5 x 50.8 mm, 55 parts (0 on the bottom side), 75 nets.

## KiCad design BeebSCSI_KiCAD/VFS_Adapter/VFS_Adapter.kicad_pcb

Parts:
C1: 100nF; C_0805
F1, F2, F3: Fiducial; Fiducial_0.5mm_Dia_1mm_Outer
J1: Internal 1MHz Bus; Pin_Header_Angled_1x20_Pitch2.54mm
J2: BeebSCSI IDC; Multicomp_MC9A12-3434_2x17x2.54mm_Straight
J3: 5V out; JST_EH_B02B-EH-A_02x2.50mm_Straight
PF1: Polyfuse; Fuse_SMD1206_HandSoldering
U1: 74HC245DW; SOIC-20W_7.5x12.8mm_Pitch1.27mm

Connections:
+5V: C1.1, J3.1, PF1.1, U1.20 (VCC)
BBC_1MHZE: J1.16, U1.13 (B5)
BBC_A0: J1.12, U1.17 (B1)
BBC_A1: J1.13, U1.16 (B2)
BBC_A2: J1.14, U1.15 (B3)
BBC_A3: J1.15, U1.14 (B4)
BBC_BD0: J1.3, J2.18
BBC_BD1: J1.4, J2.19
BBC_BD2: J1.5, J2.20
BBC_BD3: J1.6, J2.21
BBC_BD4: J1.7, J2.22
BBC_BD5: J1.8, J2.23
BBC_BD6: J1.9, J2.24
BBC_BD7: J1.10, J2.25
BBC_R/~W: J1.17, U1.12 (B6)
BBC_~IRQ: J1.1, J2.8
BBC_~MODEM: J1.11, U1.18 (B0)
BBC_~RST: J1.2, J2.14
BS_1MHZE: J2.4, U1.7 (A5)
BS_A0: J2.27, U1.3 (A1)
BS_A1: J2.28, U1.4 (A2)
BS_A2: J2.29, U1.5 (A3)
BS_A3: J2.30, U1.6 (A4)
BS_INT/~EXT: J2.26, U1.9 (A7)
BS_R/~W: J2.2, U1.8 (A6)
BS_~PGFC: J2.10, U1.2 (A0)
GND: C1.2, J1.20, J2.1, J2.3, J2.5, J2.7, J2.9, J2.11, J2.13, J2.15, J2.17, J2.31, J2.32, J2.33, J2.34, J3.2, U1.1 (A->B), U1.10 (GND), U1.19 (CE)
unnamed: J1.18, PF1.2, U1.11 (B7)

Notes on the sheet:
Note: Pin 26 (0V) is used by BeebSCSI to detect if it is connected to the internal bus, so this board provides a logic level 1 on the pin. This board should not be used with ANY other 1 Mhz bus device unless this pin is disconnected.
Note: D[0..7] requires 2K2 pull up and pull down resistors in order to be at TTL levels. Since BeebSCSI provides terminating resistors, there is no need for them here.

Board: 2 copper layers, 29.2 x 50.8 mm, 9 parts (0 on the bottom side), 28 nets.

## Code that names these connections

File BeebSCSI_AVR/BeebSCSI_AVR/fatfs/mmc_avr_spi.c (part):

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	if (debugFlag_fatfs) debugString_P(PSTR("FAT FS: power_on(): Initialising SPI and powering up card\r\n"));
	
	/* Configure MOSI/MISO/SCLK/CS pins */
	DDRB |= (1 << PB0);		// Output - CS0
	DDRB |= (1 << PB1);		// Output - CLK
	DDRB |= (1 << PB2);		// Output - MOSI
	DDRB &= ~(1 << PB3);	// Input - MISO
	DDRB |= (1 << PB4);		// Output - Power
	DDRB &= ~(1 << PB5);	// Input - CD
	
	// Enable pull ups on MISO and CD
	PORTB |= (1 << PB3);
	PORTB |= (1 << PB5);
	
	/* Turn socket power on */
	PORTB &= ~_BV(4);
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	SPCR = 0;

	/* De-configure MOSI/MISO/SCLK/CS pins (set hi-z) */
	DDRB &= ~(1 << PB0);		// Input - CS0
	DDRB &= ~(1 << PB1);		// Input - CLK
	DDRB &= ~(1 << PB2);		// Input - MOSI
	DDRB &= ~(1 << PB3);		// Input - MISO
	
	// Disable pull ups on MISO and CD
	PORTB &= ~(1 << PB3);
	PORTB &= ~(1 << PB5);

	/* Turn socket power off  */
	PORTB |= _BV(4);
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
## Commit log

2017-01-07 :tada: Added .gitattributes
2017-01-07 Initial commit
    Initial commit of BeebSCSI to GitHub
2017-01-07 Initial push of the BBC Master internal bus adapter board and schematic
    Initial push of the BBC Master internal bus adapter board and schematic
2017-01-08 Corrected README files
    Corrected README files
2017-01-11 Fixed bugs in F-Code handling
    Removed interrupt disable when sending/receiving F-Codes over SCSI
    (interrupt disable was causing serial bytes to be lost - and VFS is
    slower than ADFS, so interrupts do not effect the DMA transfer). Added
    additional check to the F-code handling function to ensure that a
    complete CR terminated F-Code response is received from the serial port
    before transfering to host via SCSI.
2017-01-19 Added SD Card Bootloader
    This update adds a SD Card based bootloader to the AVR allowing BeebSCSI
    to be flashed without the need for an AVR programmer. The BeebSCSI_AVR
    project file (for Atmel Studio 7) has also been updated so that it
    produces the required BEEBSCSI.BIN file. Note: The bootloader will
    only work with FAT16 and FAT32 compatible SD cards (i.e. typically 32Gb
    or less).
2017-01-22 Enhancements to DMA transfer debug
    Some minor enhancements to the debug output around the DMA transfer.
    The debug now reports how many bytes were received before DMA transfer
    failure. The DMA read and write routines have also been changed
    slightly to increase execution speed.
2017-02-01 Added new ROM for the BBC Master and Micro - plus enhanced BeebSCSI firmware to support the ROM
    BeebSCSI now implements two additional SCSI G6 (vendor specific)
    commands that allow the ROM to get the status of BeebSCSI and perform
    "Jukeboxing". Since ADFS only allows 4 LUNs at any one time, BeebSCSI
    allows the user to 'jukebox' the LUNs and have up to 256 sets of LUNs (a
    set of LUNs being 4 under ADFS or 8 under VFS).
    Jukeboxing allows BeebSCSI to provide up to 512 Gbytes of storage to
2017-02-02 Bug fixes and enhancements to BeebSCSI_ROM
    Fixed bug in ROM header and improved filing system detection code in the
    BeebSCSI ROM
2017-02-02 Bug fixes to filing system detection in BeebSCSI ROM
    Minor bug fixes to BeebSCSI ROM
2017-02-02 Implemented error handling and better OSWORD block code
    Implemented error handling. Changed OSWORD code to use predefined
    blocks (for code neatness) and fixed some minor bugs.
2017-02-02 Updated error handing to use correct error numbers
    Updated error handing to use correct error numbers and adjusted comments
    to be more accurate about error handling process.
2017-02-03 Minor changes to bootloader
    Fixed the bootloader main.c header (it had the incorrect module
    information)
2017-02-03 Fixed bug in ROM error handler
    Minor bug in the ROM error handler that could cause bad error messages
    (out by one error)
2017-02-04 Updated internal adapter board
    Updated internal adapter board design. The design has been changed to
    be more simple to make without the requirement for SIL cabling.
2017-02-04 Minor fixes for BBC Micro
    Added additional workspace claims as a precaution on BBC Micros. Also
    modified the IDE project file for cleaner loading in BeebEm during
    development
2017-10-01 Fixed timing bug in ttl74573 module
    Fixed timing bug in ttl74573 module
2017-10-01 Added *.htm
    Added *.htm
2017-10-01 Switch status register back to positive edge latching
    Switch status register back to positive edge latching
2018-03-18 Updated headers. Parital fix for issue #2
    Updated code headers to 2018.
    Added partial fix for issue #2 - Read6 and Write6 commands to a STOPped LUN will now auto-start the LUN (if the LUN image is available on the SD card). This does not fix the 'not found' issue.
    Debug turned on by default (for development) and reported version number bumped to V002.001.
2018-03-18 Fixed the bootloader to compile correctly in release mode #3
2018-03-18 Fixed AVR firmware to correctly compile in release mode #3
2018-03-18 Added generation of BEEBSCSI.BIN (bootloader programming file) to release configuration
2018-03-18 Update to release candidate - ready for testing
2018-03-18 Minor fix to AVR debug output
2018-03-18 Added initial code for supporting additional vendor specific commands
    Added initial code for 3 new vendor specific SCSI codes. Modified debug to change default debug output to 'on' when compiling in debug config and 'off' when compiling in release config.
2018-03-19 Added BSFATINFO and BSFATREAD G6 commands - basic command handling only
    Added two new G6 commands to test passing of custom buffers (containing file data and file information) between BeebSCSI and the host. Actual file handing functionality is not yet implemented.
2018-03-20 Added additional debug option and BSFATINFO command implemented
    Added additional debug option for tracing FAT transfer operations
    BSFATINFO command implemented - now transfers object type, object size and file name to host
2018-03-21 Added multi-block reading to the FAT handling
    Additional structural changes ready for the FAT file data transfer operations
2018-03-21 Initial working implementation of BSFATREAD command
    Command is now working, but it is very heavy on the FAT FS interaction. Needs to be stateful during multi-block transfer to speed up the overall transfer speed to the host.
    Also added hex dump code to the BSFATINFO command to allow debug on the file information data
2018-03-23 Bug fix to BSFATREAD command
2018-03-24 FAT information and file reading now fully implemented and ready for testing
    Improved overall structure and increased the efficiency of the FAT filling commands. Restructured debug to match new FAT implementation. Merged old fat.c functionality into the filesystem layer (and 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
2018-03-24 Added command to allow change of FAT transfer directory
2018-03-25 Added BeebSCSI FAT transfer utility and updated readme files
2018-03-25 Added ADL floppy image of BSTrans
2018-03-25 Fix to ROM image due to issue #5
    BeebSCSI ROM was not passing unprocessed commands to lower priority ROMs; also, in some *ROM listings, the version number was being displayed twice (this is more of a bug in the ROM listing utilities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
2018-03-25 Updated ROM help strings, fixed readme and included .rom image in github
    Final fixes for #5
2018-03-25 Additional bug fix to ROM, bumped version to 1.04
2018-05-01 Added new 7_6 PCB design
    The new 7_6 PCB design is now in KiCAD format. The following improvements have been made:
    Smaller PCB
    Clearer silkscreen layout
    4 Mounting holes for mounting in a 3D printed case
    New MicroSD card holder - card now extends over board edge for case mounting
    5V connector is JST-EH to prevent reverse connection
2018-05-01 Added new KiCAD design for the VFS adapter board
    Also updated readme and included title information in the 7_5 PCB design files
2018-05-01 Adding git ignore files to KiCAD projects
2018-05-01 Removed kicad tmp files
2018-05-01 Added fiducials for pick and place alignment
2018-05-01 Added fiducials to VFS board for easier pick and place
2018-05-01 Added protection diode to VFS adapter and updated all PDF copies
2018-05-01 Added license files for KiCAD design
2018-05-02 Interim check in of new PCB update
2018-05-03 Interim check in of board design - added back silkscreen items
2018-05-03 Finalised BeebSCSI board including USB header
2018-05-03 Finialised VFS adapter PCB
2018-05-03 Corrected version number in readme file
2018-05-06 Added design for a cartridge adaptor (prototype only)
2018-05-06 Added jpeg of cartridge adapter
2018-05-07 Added missing solder mask Gerbers to cartridge adapter
2018-05-18 Updated 7_7 Board version
    Fixes for issues #12 #11 #10 #9
    Improved silkscreen
2018-05-19 Additional changes to BeebSCSI 7_7 PCB
    Added additional grounding to CPLD. Changed EXT/INT pull-up to 2K2.
    Modified CPLD programming to set unused pins to ground and added JTAG daisy-chain configuration to device programming.
2018-05-19 Redesigned cartridge adaptor and added dual EPROM sockets plus required hardware
    Fixes issues #15 and #14
2018-05-19 Remove files accidentally included
    ISE studio seems to put it's temporary files wherever it likes...
2018-05-26 Remove old 7_5 Eagle CAD revision of schematic and board design
2018-05-26 Fix for issue #13 - Added additional (and non-optional) start up debug. Also included emulation mode and firmware version in debug output
2018-05-26 Cleaned up debug output and added USB capable board detection. Modified status LED functions ready for additional functionality
2018-05-27 Enhanced status LED control to fix #8
    Status LED is now PWM controlled. When power on the LED lights with minimum brightness. Activity now causes the LED to show maximum brightness followed by a .25 second fade out.
2018-08-02 Initial commit of 3D printable case
    Original OpenSCAD files and output STL files included. Case requires straight power connector and right-angle IDC.
2018-08-02 Modifications and corrections
    Increased logo size on upper case (smaller holes did not print well).
    Added option to remove upper case logo
    Corrected text depth on lower case
2018-08-02 Updated STL models
2018-08-02 Updated readme file
2018-08-03 Fix to centre logo correctly on upper case
2018-08-03 Included vents in lower case to save printing time
2018-08-03 Corrected logo bitmap
2018-12-08 Update ff.h
    Make definition match usage
2019-02-21 Fix transfer of files longer that a single block.
    If a file had a length of say (512 bytes +31 ) the actual transfered file would end up with 512 byte + 31 bytes of junk + 31 real bytes.
    Almost certainly a better way of fixing this.
2019-02-21 Fix File transfer as they would have extra bytes inserted
    If a file had a length of say (512 bytes +31 ) the actual transfered file would end up with 512 byte + 31 bytes of junk + 31 real bytes.
2019-03-04 filesystem.c: changed to leave scsixx.dat open as long as possible
    Leaving scsixx.dat open as long as possible and setting up FASTSEEK. This improves performance for sectors access at the end of scsixx.dat. For sectors at the end of scsixx.dat these changes save 127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
2019-03-23 Updated headers, versioning and modified filesystem.c
2019-03-23 Code style update
2019-03-24 Updated BSTrans for firmware 2.5
    Created new BASIC image and imported into ADL file for use with floppy emulation
2019-03-24 FIx for issue #20
2019-03-24 Minor fix to filesystem.c logic
2019-03-24 Bug fix and some enhancements
    Bug fix to filesystemOpenLunForRead to make it more intelligent when handling LUN changes. Added additional flush debug to make it easier to trace what's causing the flush. Fixed debug output in scsi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
2020-02-08 Fix for issues #23 and #24 and updated headers
2020-02-08 Upgraded FAT library to R0.14 issue #25 - improved LUN handling debug
2020-04-17 Add new 3D printable case design
2020-04-17 Fixed readme png link
2022-12-19 Changed readme and included quick-start LUN image into main repo
